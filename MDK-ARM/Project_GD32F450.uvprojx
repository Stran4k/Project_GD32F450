# Keil uVision project Project_GD32F450.uvprojx, settings and files
target GD32F4XX (6160000::V6.16::ARMCLANG)
  device: GD32F450VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.3.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project_GD32F450 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=9 wLevel=3
  c include: ..\Firmware\GD32F4xx_standard_peripheral\Include;..\Utilities;..\inc;..\lwip-2.2.0\src\include;..\lwip-2.2.0\src\include\ipv4;..\lwip-2.2.0\src\include\netif;..\lwip-2.2.0\src\include\lwip;..\lwip-2.2.0\port\GD32F4xx;..\lwip-2.2.0\port\GD32F4xx\Basic;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ../src/: main.c gd32f4xx_it.c gd32f4xx_enet_eval.c netconf.c ConfigurationUSARTn.c init_config.c
  group Lwip
    ../lwip-2.2.0/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-2.2.0/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c acd.c
    ../lwip-2.2.0/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip-2.2.0/src/netif/: ethernet.c
  group Lwip_port
    ../lwip-2.2.0/port/GD32F4xx/Basic/: ethernetif.c
  group GD32F4xx_EVAL
    ../Utilities/: gd32f450i_eval.h
  group Doc
    ../src/: readme.txt
  group inc
    ../inc/: gd32f4xx.h gd32f4xx_enet_eval.h gd32f4xx_it.h gd32f4xx_libopt.h lwipopts.h main.h netconf.h system_gd32f4xx.h ConfigurationUSARTn.h init_config.h protocol.h
  group CMSIS
    ../Firmware/CMSIS/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../Firmware/CMSIS/GD/GD32F4xx/Include/: gd32f4xx.h system_gd32f4xx.h
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group GD32F4xx_standard_peripheral
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
